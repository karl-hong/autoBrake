# Keil uVision project autoBrake.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003AF4 HC89S Series
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: autoBrake +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hal;..\user
  asm include: ..\user
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
  group user
    ../user/: my_printf.c bat.c key.c led.c sc7a20.c
  group hal
    ../hal/: clock.c gpio.c ie.c wdt.c
